Commit message: fixed reference frames & collisions

File: resources/GazeboRosPackages/fh_desc/smart_grasping_sandbox.urdf (robot description, URDF)
Before this commit: robot robot, 35 links, 34 joints
Joints:
- joint world_joint: origin xyz=0.0 0 1.1 rpy=0.0 0.0 0 -> xyz=0.0 0 0 rpy=0.0 0.0 0.0
